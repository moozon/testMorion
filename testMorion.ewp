# IAR project testMorion.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: D:\Projects\Stm32\IAR; D:\Projects\Stm32\IAR\Libraries; D:\Projects\Stm32\IAR\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; D:\Projects\Stm32\IAR\Libraries\STM32F10x_StdPeriph_Driver\inc; D:\Projects\Stm32\IAR\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: testMorion.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\Projects\Stm32\IAR\testMorion\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c platform_config.h
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group lib
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
